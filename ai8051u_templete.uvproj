# Keil uVision project ai8051u_templete.uvproj, settings and files
target code (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ai8051u_templete +hex
  link misc: REMOVEUNUSED
  group user
    ./: main.c
  group library
    ./: io_int.c io_int.h set_adc.c set_adc.h set_eeprom.c set_eeprom.h set_i2c.c set_i2c.h set_int.c set_int.h set_io.c set_io.h set_pwm.c set_pwm.h set_spi.c set_spi.h set_task.c set_task.h set_timer.c set_timer.h set_uart.c set_uart.h AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB stc_usb_cdc_32g.LIB
